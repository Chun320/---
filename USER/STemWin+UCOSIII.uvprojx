# Keil uVision project STemWin+UCOSIII.uvprojx, settings and files
target STenWin_UcosIII (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\OBJ;..\USER;..\XMRAM;..\MALLOC;..\FATFS\src;..\FATFS\exfuns;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SRAM;..\HARDWARE\24CXX;..\HALLIB\CMSIS\Include;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\SDIO;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\UCSOIII\uC-CPU;..\UCSOIII\uC-LIB;..\UCSOIII\uCOS-III;..\UCSOIII\UCOS_BSP;..\UCSOIII\UCOS_CONFIG;..\UCSOIII\uCOS-III\Source;..\UCSOIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCSOIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCSOIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\EWMIN\Demo\GUIBulider;..\EWMIN\STemWin\inc;..\EWMIN\STemWin\Config;..\EWMIN\STemWinHZ;..\TEXT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group TEXT
    ../TEXT/: fontupd.c mytext.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/LCD/: tftlcd.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group MALLOC
    ../MALLOC/: malloc.c
  group XMRAM
    ../XMRAM/: XMRAM.h XMRAM.lib
  group DSP_Lib
    ../HALLIB/CMSIS/Include/: arm_math.h
    ../HALLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group UCOSIII_BSP
    ../UCSOIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCSOIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCSOIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCSOIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCSOIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_PORT
    ../UCSOIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CORE
    ../UCSOIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_CONFIG
    ../UCSOIII/UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group EMWIN_HZ
    ../EWMIN/STemWinHZ/: GUICharPEx.c GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_UC_EncodeNone.c
  group EMWIN_LIB
    ../EWMIN/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
  group ENWIN_CONFIG
    ../EWMIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EWMIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_DEMO
    ../EWMIN/Demo/GUIBulider/: laserdata.c
